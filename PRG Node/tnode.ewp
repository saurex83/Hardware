# IAR project tnode.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\Neocore\Hardware\Stack_core_src
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group high protocol
    ../Stack_core_src/: alarm_timer.h
    ./: auth_eth.c auth_eth.h auth_ip.c auth_ip.h balancer.c balancer.h controller.c controller.h ethernet.c ethernet.h ip.c ip.h neigh.c neigh.h protocol_defs.h route.c route.h tcp.c tcp.h udp.c udp.h vtimer.c vtimer.h
  group stack core
    ../STACK_CORE_SRC/: action_manager.c alarm_timer.c coder.c cpu.h debug.c frame.c llc.c llc.h mac.c mac.h macros.h mem_slots.c mem_slots.h mem_utils.c mem_utils.h model.c modules_list.h radio.c radio_defs.h sync.c time_manager.c ustimer.c
    ../Stack_core_src/: action_manager.h basic.h coder.h config.c config.h cpu.c debug.h dma.c dma.h frame.h global.h led.c led.h list.h meta.h model.h model_import_struct.h radio.h rtc.c rtc.h sync.h time_manager.h ustimer.h
  group tnode
    ./: auth.c auth.h
