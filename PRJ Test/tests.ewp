# IAR project tests.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\Neocore\Hardware\Stack_core_src
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
    ../STACK_CORE_SRC/: NOTE.txt
  group stack core
    ../STACK_CORE_SRC/: action_manager.c alarm_timer.c buffer.c coder.c cpu.c debug.c dma.c dma.h frame.c led.c led.h list.h llc.c llc.h mac.c mac.h mem_slots.c mem_utils.c model.c modules_list.h rtc.c sync.c time_manager.c ustimer.c
    ../Stack_core_src/: action_manager.h alarm_timer.h buffer.h coder.h cpu.h debug.h frame.h global.h macros.h mem_slots.h mem_utils.h meta.h model.h model_import_struct.h radio.c radio.h radio_defs.h rtc.h sync.h time_manager.h ustimer.h
  group text
    ../STACK_CORE_SRC/: ideas.txt rules.txt tempalte.txt
  group unit tests
    ./: modules_test_list.h u_alarm_timer.c u_buffer.c u_debug.c u_frame.c u_macros.c u_mem_slots.c u_mem_utils.c utest.c utest.h
